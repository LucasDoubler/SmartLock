# Keil uVision project SMTP_Client.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.1-dev9
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: SMTP_Client
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_IOEXPANDER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x1e000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source
    ./: SMTP_Client.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Inc/: stm32h7xx_it.h
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.1-dev9
  cpu: as above
  output: SMTP_Client
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_IOEXPANDER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.10.0, Network:CORE 7.10.0, Network:Interface:ETH 7.10.0, Network:Service:DNS Client 7.10.0, Network:Service:SMTP Client 7.10.0, Network:Socket:TCP 7.10.0, Network:Socket:UDP 7.10.0, Board Support:A/D Converter 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Graphic LCD 1.1.0, Board Support:LED 1.1.0, CMSIS Driver:Ethernet MAC 1.1.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.2.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:ETH 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:LTDC 1.5.0, Device:STM32Cube HAL:MDMA 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:Startup 1.5.0
