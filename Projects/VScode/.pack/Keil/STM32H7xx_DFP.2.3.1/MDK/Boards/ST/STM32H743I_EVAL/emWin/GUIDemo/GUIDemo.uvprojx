# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1-dev1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_IOEXPANDER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20001000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source
    ./: GUIDemo.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743XIHx/STCubeGenerated/Inc/: stm32h7xx_it.h
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1-dev1
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_IOEXPANDER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Drivers:Touch Screen 1.1.0, Board Support:Joystick 1.1.0, Board Support:Touchscreen 1.1.0, Board Support:emWin LCD 1.1.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:DMA2D 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:LTDC 1.5.0, Device:STM32Cube HAL:MDMA 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:Startup 1.5.0, Graphics Display:STM32H743I-EVAL 1.0.2, Graphics:CORE 5.50, Graphics:Demo:AntialiasedText 5.50, Graphics:Demo:Automotive 5.50, Graphics:Demo:BarGraph 5.50, Graphics:Demo:Bitmap 5.50, Graphics:Demo:ColorBar 5.50, Graphics:Demo:Cursor 5.50, Graphics:Demo:Fading 5.50, Graphics:Demo:Framework 5.50, Graphics:Demo:Graph 5.50, Graphics:Demo:IconView 5.50, Graphics:Demo:ImageFlow 5.50, Graphics:Demo:ListView 5.50, Graphics:Demo:RadialMenu 5.50, Graphics:Demo:Skinning 5.50, Graphics:Demo:Speed 5.50, Graphics:Demo:TransparentDialog 5.50, Graphics:Demo:Treeview 5.50, Graphics:Demo:VScreen 5.50, Graphics:Demo:WashingMachine 5.50, Graphics:Input Device:Joystick 5.50, Graphics:Input Device:Touchscreen 5.50
